# Keil uVision project Do_test.uvproj, settings and files
target Do_test_flashmode (ARM-ADS)
  device: STM32F101VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: do_test +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_FULL_ASSERT,USE_STDPERIPH_DRIVER,WATCHDOG
  c include: ..\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS;..\user;..\BSP;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group cmsis
    ../CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_cl.s stm32f10x.h system_stm32f10x.h
  group std_periph_driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_i2c.c stm32f10x_dma.c
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group bsp
    ../BSP/: bsp.c BaseBus_Protocol.c I2CRoutines.c
