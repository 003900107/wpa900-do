# IAR project Do_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_FULL_ASSERT; USE_STDPERIPH_DRIVER; WATCHDOG
  ICCARM.CCIncludePath2: ..\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS; ..\user; ..\BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: Do_test.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../BSP/: BaseBus_Protocol.c bsp.c I2CRoutines.c
  group cmsis
    ../CMSIS/: core_cm3.c
    ./: startup_stm32f10x_cl.s
  group std_periph_driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
